# Keil uVision project task16.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: task16 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 mian.c lcd.c lcd.h delay.c delay.h function.c function.h
    ../../task 19/state/: calculator.h calculator.c state.c
